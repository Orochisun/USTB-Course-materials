<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x5355;&#x5143;6&#x4eFB;&#x52A1;1.ewp</path>
  </project>
  <batchBuild/>
</workspace>


